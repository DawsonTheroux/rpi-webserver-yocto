IMAGE_INSTALL:append = " \
		kernel-modules \
		nftables \
		nginx \
		openssh \
		portfolio-website \
		"	
