PARALLEL_MAKE = "-j2"
BB_NUMBER_THREADS = "2"
